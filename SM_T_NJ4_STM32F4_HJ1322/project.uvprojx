# Keil uVision project project.uvprojx, settings and files
target Homer4L (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_STDPERIPH_DRIVER
  c include: .\app;.\drivers;.\freertos\inc;.\stm32lib\STM32F4xx_StdPeriph_Driver\inc;.\stm32lib\CMSIS\Device\ST\STM32F4xx\Include;.\stm32lib\CMSIS\Include;.\ringbuffer;.\pro_data;.\common
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./app/: main.c app_led.c app_gnss.c app_shell.c app_packet.c app_fifo.c app_products.c app_sms.c version.c app_at.c app_lte.c app_can_recv.c app_can_send.c app_iap.c app_in.c app_gb4.c
  group drivers
    ./drivers/: board.c drv_gpio.c drv_uart.c drv_rtc.c drv_timer.c drv_can.c drv_nor_flash.c drv_i2c.c drv_emmc.c
  group freertos
    ./freertos/src/: croutine.c event_groups.c heap_4.c list.c port.c queue.c tasks.c timers.c
  group stm32f4lib
    ./stm32lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group cmsis
    ./stm32lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group startup
    ./stm32lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group components
    ./components/: components.c
  group fatfs
    ./fatfs/: diskio.c ff.c
  group ringbuffer
    ./ringbuffer/: ringbuffer.c
  group pro_data
    ./pro_data/: md5.c md5_code.c pro_data.c
