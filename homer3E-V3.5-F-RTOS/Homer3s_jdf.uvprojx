# Keil uVision project Homer3s_jdf.uvprojx, settings and files
target Homer3E-V3.5 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Homer3X20180206 +hex
  AfterMake: fromelf --bin ./Debug/Obj/Homer3X20180206.axf --output ./Debug/LW3SSTM32.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\drivers;.\common;.\lib\inc;.\cmsis\inc;.\rtos\inc;.\user\inc
  memory RVCT4: ROM 0x8000000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ./user/src/: main.c md5.c version.c gnss.c gsm.c pro_data.c rtc.c ddp.c config.c mon.c can.c fifo.c
  group rtos
    ./rtos/src/: croutine.c event_groups.c list.c port.c queue.c tasks.c timers.c console.c heap_4.c
  group lib
    ./lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ./cmsis/src/: core_cm3.c system_stm32f10x.c
  group startup
    ./startup/: startup_stm32f10x_hd.s
  group drivers
    ./drivers/: board.c fr_drv_rtc.c fr_drv_can.c fr_drv_i2c.c fr_drv_mem.c fr_drv_spi.c fr_drv_adc.c fr_drv_timer.c fr_drv_uart.c fr_drv_gpio.c fr_drv_iap.c spi_flash_gd.c
software components: CMSIS:CORE 5.1.1
